v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {nmoscs.sym} -40 -70 0 0 {name=x1}
C {nmoscs2.sym} -40 70 0 0 {name=x2}
C {pmoscs.sym} 370 -70 2 0 {name=x3}
C {pmosdiff.sym} 370 80 2 0 {name=x4}
C {devices/lab_pin.sym} 220 -100 0 0 {name=p5 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 220 -80 0 0 {name=p1 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 220 -60 0 0 {name=p2 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 220 -40 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 220 50 0 0 {name=p4 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 220 70 0 0 {name=p6 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 220 90 0 0 {name=p7 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 110 90 2 0 {name=p8 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 110 70 2 0 {name=p9 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 110 50 2 0 {name=p10 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 110 -40 2 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 110 -60 2 0 {name=p12 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 110 -80 2 0 {name=p13 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 110 -100 2 0 {name=p14 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 520 90 2 0 {name=p15 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 520 110 2 0 {name=p16 sig_type=std_logic lab=VIP}
C {devices/lab_pin.sym} 220 110 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/iopin.sym} 730 -200 0 0 {name=p18 lab=VDD}
C {devices/iopin.sym} 730 -160 0 0 {name=p19 lab=GND}
C {devices/iopin.sym} 730 -120 0 0 {name=p20 lab=RS}
C {devices/iopin.sym} 730 -90 0 0 {name=p21 lab=VIN}
C {devices/iopin.sym} 730 -60 0 0 {name=p22 lab=VIP}
C {devices/iopin.sym} 730 -30 0 0 {name=p23 lab=OUT}
